# Keil uVision project UART0_interrupt.uvprojx, settings and files
target UART0_interrupt (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: FM33LC02X FMSH
  pack: Keil.FM33LC0XX_DFP.3.0.1
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x6000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: UART0_interrupt +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: FM33LC0XX,USE_FULL_ASSERT,MFANG
  c include: ..\Drivers\CMSIS\Inculde;..\Drivers\FM33LC0xx_FL_Driver\Inc;..\Drivers\CMSIS\Device\FM\FM33xx\Include;..\MF-config\Inc;..\Inc
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/FM/FM33xx/Source/Templates/arm/: startup_fm33lc0xx.s
  group Application/MF-Config
    ../MF-config/Src/: mf_config.c
    ../Src/: uart0_interrupt.c
  group Application/User
    ../Src/: main.c user_init.c pll.c menu.c a_i2c.c ad5412_spi.c bsp_spi.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/FM/FM33xx/Source/: system_fm33lc0xx.c
    ../Src/: vi_sw_i2c.c VI5300_API.c VI5300_Firmware.c VI5300_UserPlatform.c
  group Drivers/FM33LC0xx_FL_Driver
    ../Drivers/FM33LC0xx_FL_Driver/Src/: fm33lc0xx_fl.c fm33lc0xx_fl_adc.c fm33lc0xx_fl_aes.c fm33lc0xx_fl_atim.c fm33lc0xx_fl_bstim32.c fm33lc0xx_fl_comp.c fm33lc0xx_fl_crc.c fm33lc0xx_fl_dma.c fm33lc0xx_fl_flash.c fm33lc0xx_fl_gpio.c fm33lc0xx_fl_gptim.c fm33lc0xx_fl_divas.c fm33lc0xx_fl_i2c.c fm33lc0xx_fl_iwdt.c fm33lc0xx_fl_lptim32.c fm33lc0xx_fl_lpuart.c fm33lc0xx_fl_opa.c fm33lc0xx_fl_pmu.c fm33lc0xx_fl_rcc.c fm33lc0xx_fl_rng.c fm33lc0xx_fl_rtc.c fm33lc0xx_fl_spi.c fm33lc0xx_fl_svd.c fm33lc0xx_fl_u7816.c fm33lc0xx_fl_uart.c fm33lc0xx_fl_wwdt.c fm33lc0xx_fl_lcd.c
